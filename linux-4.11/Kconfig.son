## linux-4.11/Kconfig.son
```kconfig
menu "SON"

config SON
	tristate "Enable Page Scanning support."
# tristate : yes, module, no
	default n
endmenu
```
